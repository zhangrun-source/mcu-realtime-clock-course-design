# Keil uVision project c1.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8031 (all Variants) Generic
  cpu: IRAM(0-0x7F) CLOCK(12000000)
  output: c1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 c1.c
